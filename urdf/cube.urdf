Commit message: Fix surface point sampling

File: urdf/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- removed link cube
- added link cube_1, mass 0.1; collision box size=0.103 0.103 0.103; visual box size=0.103 0.103 0.103
